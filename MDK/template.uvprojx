# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.8
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403ARGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1,ARM_MATH_CM4,__TARGET_FPU_VFP,__FPU_PRESENT
  c misc: --locale=english
  c include: ..\libraries\cmsis\cm4\core_support;..\libraries\cmsis\cm4\device_support;..\libraries\drivers\inc;..\user\inc;..\freertos\source\include;..\freertos\source\portable\memmang;..\freertos\source\portable\rvds\ARM_CM4F;..\Libraries\cmsis\dsp\include;..\AppLayer\system;..\Tools;..\HardwareLayer;..\DriverLayer;..\AlgorithmLayer;..\Communication
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group User
    ../user/src/: at32f403a_407_clock.c at32f403a_407_int.c include_port.c main.c
    ../user/inc/: FreeRTOSConfig.h
  group Firmware
    ../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group cmsis
    ../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group Freertos
    ../freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/source/portable/memmang/: heap_4.c
  group Dsp
    ../Libraries/cmsis/dsp/Source/CommonTables/: arm_common_tables.c
    ../Libraries/cmsis/dsp/Source/FastMathFunctions/: arm_cos_f32.c arm_sin_f32.c
  group System
    ../AppLayer/system/: delay.c delay.h sys_cfg.h system_init.c system_init.h app_tasks.c app_tasks.h task_config.h system_monitor.c system_monitor.h
  group Tools
    ../TOOLS/: log.c log.h
  group HardwarelLayer
    ../HardwareLayer/: foc_cfg.h motor_adc.h motor_adc.c motor_timr.h motor_timr.c my_spi.c my_spi.h my_usart.c my_usart.h my_flash.c my_flash.h my_can.c my_can.h
  group DriverLayer
    ../DriverLayer/: switch.c switch.h lcd.c lcd.h lcd_font.h as5047p.c as5047p.h drv8301.c drv8301.h foc.c foc.h
  group AlgorithmLayer
    ../AlgorithmLayer/: pid.c pid.h ramp_generator.c ramp_generator.h lowpass_filter.c lowpass_filter.h foc_algorithm.c foc_algorithm.h
  group AppLayer
    ../AppLayer/motor_control/: motor_service.c motor_service.h
  group Communication
    ../Communication/: can_business.c can_business.h uart_business.c uart_business.h
